Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2022-03-30T17:50:29
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190108_1515(x64) - Exporter 19.2.1.1 - 代替 UI 19.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Mar 30 17:50:29 2022 * Host: N174135 * Database: C:\Users\nohara\AppData\Local\Temp\{A5FAEE44-51A5-4955-8E47-B0BBDCB02602}\ifc * Database version: 5507 * Database creation date: Wed Mar 30 17:50:28 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Mar 30 17:50:28 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Mar 30 17:50:28 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, レベル 1
LongName: レベル 1; Elevation: 0 mm

# IfcBuildingElementProxy: AJY342-378LALDH, HVAC_Air-Conditioning_Fujitsu General_V-IV AJY342-378LALDH:AJY342-378LALDH:50270
In: レベル 1
Type - Material: Color RGB 110-110-110, Color RGB 212-204-191, Color RGB 216-216-216, Color RGB 040-040-040
Pset_BuildingElementProxyCommon - Reference: AJY342-378LALDH
Pset_ManufacturerTypeInformation - Manufacturer: FUJITSU GENERAL LIMITED
